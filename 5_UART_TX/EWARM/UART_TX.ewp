# IAR project UART_TX.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F401xE; USE_HSE_BYPASS
  ICCARM.CCIncludePath2: settings; ; ../; ../CMSIS; ../Config_Manual; ../Std_Periph; ../user
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: UART_TX.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: settings\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../CMSIS/: startup_stm32f401xx.s system_stm32f4xx.c
  group Std_Periph
    ../Std_Periph/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
  group user
    ./: main.c
