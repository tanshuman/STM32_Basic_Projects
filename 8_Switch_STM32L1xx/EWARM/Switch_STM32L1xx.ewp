# IAR project Switch_STM32L1xx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152RE ST STM32L152RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_XL
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; ../CMSIS; ../Manual_Config; ../Std_Periph; ../user
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Switch_STM32L1xx.bin
  ILINK.IlinkOutputFile: Switch_STM32L1xx.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../CMSIS/: startup_stm32l1xx_xl.s system_stm32l1xx.c
  group Std_Periph
    ../Std_Periph/: misc.c stm32l1xx_gpio.c stm32l1xx_rcc.c
  group user
    ../user/: main.c
