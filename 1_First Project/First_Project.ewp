# IAR project First_Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: C:\Users\masta\Documents\IAR Workbench\First Project\CMSIS\Include; C:\Users\masta\Documents\IAR Workbench\First Project\CMSIS; C:\Users\masta\Documents\IAR Workbench\First Project\StdPeriph\inc; C:\Users\masta\Documents\IAR Workbench\First Project\StdPeriph; C:\Users\masta\Documents\IAR Workbench\First Project\StdPeriph\src; C:\Users\masta\Documents\IAR Workbench\First Project; C:\Users\masta\Documents\IAR Workbench\Library\STM32F4xx_DSP_StdPeriph_Lib_V1.7.1\Libraries\STM32F4xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    CMSIS/: startup_stm32f401xx.s
  group StdLib
    StdPeriph/src/: misc.c
  group user
    ./: main.c
    CMSIS/: system_stm32f4xx.c
